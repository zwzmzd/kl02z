# IAR project templete.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templete.out
configuration mkl02z4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL02Z32xxx4 Freescale MKL02Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MKL02Z4; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\KL\inc; ..\..\..\..\Libraries\devices\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport; ..\src
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Freescale\MKL02Z32xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group devices
    ../../../../Libraries/devices/src/: at24cxx.c w25qxx.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: adc.c common.c gpio.c i2c.c spi.c systick.c uart.c
  group startup
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MKL02Z4.s
    ../../../../Libraries/startup/DeviceSupport/: system_MKL02Z4.c
  group user
    ../src/: adc_test.c bme_test.c gpio_test.c i2c_test.c lowpower_test.c main.c spi_test.c
