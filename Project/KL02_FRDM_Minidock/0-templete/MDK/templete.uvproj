# Keil uVision project templete.uvproj, settings and files
target mkl02z4 (ARM-ADS)
  device: MKL02Z32xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFFC00,0x1000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: templete +hex
  c flags: uC99=1
  c define: MKL02Z4 FRDM
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\src;..\..\..\..\Libraries\drivers\KL\inc;..\src;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\devices\src
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group startup_mkl02z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL02Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL02Z4.s
  group user
    ../src/: gpio_test.c main.c spi_test.c adc_test.c i2c_test.c bme_test.c lowpower_test.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c flash.c gpio.c spi.c systick.c uart.c adc.c i2c.c
  group devices
    ../../../../Libraries/devices/src/: w25qxx.c at24cxx.c
